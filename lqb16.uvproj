# Keil uVision project lqb16.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lqb16 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver\inc;.\device\inc
  group startup
    ./: STARTUP.A51
  group driver
    ./driver/src/: delay.c i2c.c
  group device
    ./device/src/: smg.c key.c timer.c hc573.c ds18b20.c utralsound.c led.c pcf8591.c relay.c
  group user
    ./user/: main.c
